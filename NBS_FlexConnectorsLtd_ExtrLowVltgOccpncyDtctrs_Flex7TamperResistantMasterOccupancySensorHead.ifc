Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2015-11-06T12:17:34
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20131024_2115(x64) - Exporter 3.13.0.0 - Alternate UI 2.12.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Fri Nov 06 12:17:34 2015* Host: NCL-PI07* Database: C:\Users\MorrenA\AppData\Local\Temp\{3AB62E8D-2CEB-4BF9-9BA3-117BC6D04152}\ifc* Database version: 5507* Database creation date: Fri Nov 06 12:17:34 2015* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Fri Nov 06 12:17:34 2015* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Fri Nov 06 12:17:34 2015* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDistributionControlElement: Master, NBS_FlexConnectorsLtd_ExtrLowVltgOccpncyDtctrs_Flex7TamperResistantMasterOccupancySensorHead:Master:229153
In: Level 0
Type - PredefinedType: MOVEMENTSENSOR; Classification: Pr_70_70_47_16 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_FlexConnectorsLtd_ExtraLowVoltageOccupancyDetectors_Flex7OccupancySensorHead_MasterHead-TamperResistant; ManufacturerName: Flex Connectors Ltd; ManufacturerURL: www.flexconnectors.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/ihk4b3yk; NBSDescription: Extra-low voltage occupancy detectors; NBSReference: 90-65-05/420; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSTypeID: n/a; ProductInformation: www.flexconnectors.co.uk/products/control/occupancy-sensor-heads; Revision: n/a; Uniclass2015Version: Products v1.4; Version: 2; Uniclass2015Title: Combined daylight and occupancy detectors; Uniclass2015Code: Pr_70_70_47_16
Type - NBS_Data - AdjustableSensorSettings: Not required; EquipmentInterconnectivity: n/a; FieldOfView: Fixed; Format: n/a; IngressProtectionMinimum: IP20; Mounting: n/a; MountingOptions: Ceiling, flush, surface; OccupancySensitivity: Adjustable; OperatingTemperatureRange: -10 to 40°C; Range: Fixed; RemoteSetupOverride: By infrared controller; SensorRange: 7.42 m x 5.66 m at 2.5m height
Type - Pset_SensorTypeCommon - Reference: n/a
Type - Pset_SensorTypeMovementSensor - MovementSensingType: Other; TimeConstant: 0
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_70_47_16:Combined daylight and occupancy detectors; CodePerformance: LVD-2006/95/EC: EMC-2004/108/EC; Color: White; Constituents: n/a; Description: The tamper-resistant PIR (passive infra-red) detector senses movement and sends the information back to the Lighting Control Pack; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: info@flexconnectors.co.uk; Material: Nylon - PA6 UL94 V-0 rated; ModelNumber: fnh200/s; ModelReference: flex7 Master Tamper-resistant Occupancy Sensor Head; Name: ExtraLowVoltageOccupancyDetectors_Flex7TamperResistantMasterOccupancySensorHead_FlexConnectorsLtd; NominalHeight: 33.2 mm; NominalLength: 68 mm; NominalWidth: 68 mm; ReplacementCost: n/a; Shape: Cylindrical; Size: 68 dia x 33.2 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
